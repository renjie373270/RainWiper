# Keil uVision project RainWiper.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RainWiper +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib;.\user;.\CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/: misc.c stm32f10x_gpio.c stm32f10x_systick.c stm32f10x_rcc.c
  group user
    ./user/: main.c
  group startup
    ./startup/: startup_stm32f10x_md.s
